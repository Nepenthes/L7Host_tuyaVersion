# Keil uVision project L7vTuya_netgateMaster.uvprojx, settings and files
target Zigbee(cc2530)&WIFI(WRG1) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F401CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: L7vTuya_netgateMaster +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: .\usrMain;.\dataTransmission;.\timerActuator;.\bspDrv_devIpt;.\bspDrv_devOpt
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group usrMain
    ./usrMain/: usrMain.c dataManage.c usrAppMethod.c usrManage_halHwCallbcak.c
  group dataTransmission
    ./dataTransmission/: datsProcess_uartWifi.c datsProcess_uartZigbee.c UART_dataTransfer.c
  group timerActuator
    ./timerActuator/: bussiness_timerHard.c bussiness_timerSoft.c timer_Activing.c
  group bspDrv_devIpt
    ./bspDrv_devIpt/: bspDrv_iptDevice.c
  group bspDrv_devOpt
    ./bspDrv_devOpt/: bspDrv_optDevTips.c bspDrv_optDevRelay.c
software components: CMSIS:CORE 5.1.1, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:USART 2.5, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:Flash 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:IWDG 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:TIM 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:STM32Cube HAL:USART 1.4.2, Device:Startup 2.4.2
